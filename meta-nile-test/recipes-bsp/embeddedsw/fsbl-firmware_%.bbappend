CFLAGS:append:genesyszu-3eg = " -DXPS_BOARD_GZU_3EG -DFSBL_DEBUG"
CXXFLAGS:append:genesyszu-3eg = " -DXPS_BOARD_GZU_3EG -DFSBL_DEBUG"
